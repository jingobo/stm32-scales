# IAR project scales.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; STM32L476xx
  ICCARM.CCIncludePath2: source; source\cmsis\Include; source\cmsis\Device\ST\STM32L4xx
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: scales.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    source/: adc.cpp gfx.cpp io.cpp lcd.cpp main.cpp mcu.cpp nvic.cpp spi.cpp
  group include
    source/: system.h typedefs.h
